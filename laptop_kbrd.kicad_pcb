# Repository dileepvr/novenaX_kicad

File README.md:

These are kicad schematics and design files for PCBs used in the
Novena-X project, which aims to build a laptop around the Novena
motherboard released by Kosagi. These design files are being released
(as of this writing on the 30th of April, 2016) under the CERN Open
Hardware License v1.2 (see file LICENSE.txt for text of the license).
All future versions of the CERN Open Hardware License automatically
apply.

For more information about the Novena motherboard, visit: http://www.kosagi.com/w/index.php?title=Novena_Main_Page

For more information about Project Novena-X, visit: http://rightshift.info and refer to the posts titled "Project Novena-X"

The PCB is split into three circuits. One of them is meant to
interface between the Novena front-panel FFC cable and a Dell 0WX4JF
backlit keyboard. It also consists of LEDs driven by six pins from the
FPGA onboard the Novena, as well as buttons for power, reset, and
bluetooth association. The board houses an ATMEGA32u4 microcontroller.

A second circuit merely hosts a pushbutton meant to detect when the case is open/closed.

The third circuit communicates through specific pins on Novena's LVDS
panel FFC cable, and houses two ATMEGA32u4 microcontrollers, as well
as a USB hub (TUSB2046BVFR). This circuit interfaces with an
NHD-044DAZ-FL-YBW 40x4 character LCD screen from New Haven displays,
an e-ink panel arduino shield called ePaper v2 by Seeedstudio, a USB
camera, an nRF24L01+ radio module from Nordic, as well as i2c chips
such as the BME280 weather monitor, the ATAE5132A encrypted EEPROM,
and a AT97SC3205T TPM chip from Atmel.

- Dileep V. Reddy

## KiCad design laptop_kbrd.kicad_pcb

Parts:
C1, C8: 0.1uF
C2, C3: 22pF
C4, C5, C6: 1uF
C7: 100uF
CON1: AVR-ISP-6-DR; AVR-ISP-6
D1: FPGA_CLK
D2: FPGA_WP
D3: FPGA_MISO
D4: FPGA_MOSI
D5: FPGA_HOLD
D6: FPGA_CS
D7: LED_YELLOW
D8: LED_BLUE
D9: RSA5M
DNP1: 0
K1, K2: CASE_OPEN
MUX1, MUX2, MUX3: CD4051
P1: CPU_FAN
Q1, Q2, Q3, Q4, Q5, Q6, Q7: MOSFET_N
Q8: ALS_PT19
R1, R3, R4, R6, R8, R9, R11, R13, R14, R15, R16, R19, R20, R22, R24: 10K
R2, R5, R7, R10, R12, R17, R18, R21: 1K
R23: 47K
SW1: MCU_RST
SW2: BT_ASSCN
SW3: POWER
SW4: CASE_PUSH
U1: ATMEGA32U4-AU
U2: RT9706
U4: 0WX4JF
U5: XF2M-3015-1A
X1: XTAL 16MHz

Connections:
/3.3V_DELAYED: C1.2, D8.1 (A), K1.1, R19.2, R22.2, U5.7
/5V_DELAYED: C5.1, D7.1 (A), Q8.3 (C), U2.4 (VIN), U5.14, U5.15
/A: MUX1.11 (A), MUX2.11 (A), MUX3.11 (A), U1.41
/B: MUX1.10 (B), MUX2.10 (B), MUX3.10 (B), U1.40
/BL_CNT: U1.1, U4.39 (CTRL)
/C: MUX1.9 (C), MUX2.9 (C), MUX3.9 (C), U1.39
/CHG_PWRSWITCH: SW3.3, U5.13
/COM1: MUX1.3 (COM), R13.1, U1.28
/COM2: MUX2.3 (COM), R14.1, U1.29
/COM3: MUX3.3 (COM), R15.1, U1.30
/D+: U1.4, U5.24
/D-: U1.3, U5.25
/EPIT1_EPIT0: R9.1, U2.1 (~EN), U5.8
/FPGA CLK: Q1.G, R1.1, U5.22
/FPGA CS: Q6.G, R16.1, U5.16
/FPGA HOLD: Q5.G, R11.1, U5.17
/FPGA MISO: Q3.G, R6.1, U5.20
/FPGA MOSI: Q4.G, R8.1, U5.18
/FPGA WP: Q2.G, R4.1, U5.21
/GPT_CAPIN1: DNP1.2, U5.12
/GPT_CMPOUT3: Q7.G, U5.11
/KEY_COL3: K1.2 (PM), U5.10
/KEY_ROW1: C8.1, R22.1, SW2.4, U5.9
/MISO: CON1.1 (MISO), U1.11
/MOSI: CON1.4 (MOSI), U1.10
/P1: U1.31, U4.1
/P2: U1.32, U4.2
/P3: U1.18, U4.3
/P4: U1.19, U4.4
/P5: U1.20, U4.5
/P6: U1.21, U4.6
/P8: U1.25, U4.8
/P9: U1.26, U4.9
/P10: U1.27, U4.10
/RST: CON1.5 (RST), R3.2, SW1.4, U1.13
/SCK: CON1.3 (SCK), U1.9
/TRACK_HORI: U1.37, U4.36
/TRACK_VERT: U1.38, U4.35
/TS_ANA: Q8.1 (E), R20.2, U5.6
GND: C1.1, C4.2, C5.2, C6.2, C7.1, C8.2, CON1.6 (GND), D9.1 (A), K1.3, MUX1.6 (INH), MUX1.7 (Vee), MUX1.8 (GND), MUX2.6 (INH), MUX2.7 (Vee), MUX2.8 (GND), MUX3.2 (6), MUX3.4 (7), MUX3.5, MUX3.6 (INH), MUX3.7 (Vee), MUX3.8 (GND), P1.1, Q1.S, Q2.S, Q3.S, Q4.S, Q5.S, Q6.S, Q7.S, R1.2, R4.2, R6.2, R8.2, R9.2, R11.2, R13.2, R14.2, R15.2, R16.2, R20.1, R24.1, SW1.2, SW2.2, SW3.2, U1.5, U1.15, U1.23, U1.35, U1.43, U2.2 (GND), U4.34, U4.40 (GND), U5.5, U5.19, U5.23, U5.27, X1.2 (case), X1.4
unnamed: MUX3.1 (4), U4.32
unnamed: C2.2, U1.17
unnamed: C3.2, U1.16
unnamed: C2.1, X1.3
unnamed: C3.1, X1.1
unnamed: MUX2.12 (3), U4.21
unnamed: MUX2.1 (4), U4.22
unnamed: MUX2.5, U4.23
unnamed: MUX2.2 (6), U4.24
unnamed: MUX2.4 (7), U4.25
unnamed: MUX3.13 (0), U4.26
unnamed: MUX3.14 (1), U4.27
unnamed: MUX3.15 (2), U4.28
unnamed: MUX3.12 (3), U4.29
unnamed: MUX1.15 (2), U4.12
unnamed: MUX1.12 (3), U4.13
unnamed: MUX1.1 (4), U4.14
unnamed: MUX1.5, U4.15
unnamed: MUX1.2 (6), U4.16
unnamed: MUX1.4 (7), U4.17
unnamed: MUX2.13 (0), U4.18
unnamed: MUX2.14 (1), U4.19
unnamed: MUX2.15 (2), U4.20
unnamed: C4.1, U1.6
unnamed: DNP1.1, R19.1, U2.3 (~FLG)
unnamed: R24.2, U1.33
unnamed: K2.3, R23.1
unnamed: K2.1, SW4.4
unnamed: K2.2 (PM), R23.2, SW4.2
unnamed: D1.2 (K), R2.1
unnamed: Q1.D, R2.2
unnamed: D8.2 (K), R21.2
unnamed: R21.1, SW2.3
unnamed: D2.2 (K), R5.1
unnamed: Q2.D, R5.2
unnamed: Q7.D, R18.2
unnamed: D5.2 (K), R12.1
unnamed: D3.2 (K), R7.1
unnamed: Q3.D, R7.2
unnamed: D4.2 (K), R10.1
unnamed: Q4.D, R10.2
unnamed: Q5.D, R12.2
unnamed: D6.2 (K), R17.1
unnamed: Q6.D, R17.2
unnamed: D7.2 (K), R18.1
unnamed: MUX1.13 (0), U4.7
unnamed: MUX1.14 (1), U4.11
VCC: C7.2, CON1.2 (VCC), D9.2 (K), MUX1.16 (Vdd), MUX2.16 (Vdd), MUX3.16 (Vdd), R3.1, U1.2, U1.7, U1.14, U1.24, U1.34, U1.44, U5.26, U5.30
VDD: C6.1, D1.1 (A), D2.1 (A), D3.1 (A), D4.1 (A), D5.1 (A), D6.1 (A), P1.2 (PM), U2.5 (VOUT), U4.37, U4.38 (VCC)

Parts:
C9, C10, C11, C12, C20, C22, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34: 22pF
C13, C14, C19: 1uF
C15, C17, C23, C24: 0.1uF
C16, C18, C21: 2.2nF
CON2, CON3: AVR-ISP-6-DR; AVR-ISP-6
JP1: JUMPER
Q9, Q10, Q11: MOSFET_N
R25, R26, R27, R28, R36, R37, R38, R41: 10K
R29, R35: 4.7K
R30, R31: 1K
R32: 15K
R33, R34: 1.5K
R39, R40, R42, R43, R44, R45, R46, R47, R48, R49: 27
SW5, SW6: MCU_RST
SW7: SPST
U3, U6: ATMEGA32U4
U7: USB_CAM
U8: EPAPER_V2
U9: USB_A_FEMALE
U10: NHD-0440AZ-FL-YBW
U11: NRF24L01+
U12: ATAES132A
U13: AT97SC3205T
U14: TUSB2046BVFR
U16: BME280
U17: TPS2041B
X2, X3: XTAL 16MHz
X4: 6MHz

Connections:
/LCD_board/D1+: C27.2, R43.2, U9.3 (D+)
/LCD_board/D1-: C28.2, R42.2, U9.2 (D-)
/LCD_board/D2+: C29.2, R45.2, U6.4
/LCD_board/D2-: C30.2, R44.2, U6.3
/LCD_board/D4+: C33.2, R46.1, U3.4
/LCD_board/D4-: C34.2, R47.1, U3.3
/LCD_board/Din+: C25.2, R39.2; also elsewhere on the board
/LCD_board/Din-: C26.2, R40.2; also elsewhere on the board
/LCD_board/EP_A0: U6.36, U8.13 (M_TEMP_SEN)
/LCD_board/EP_A1: U6.37, U8.14 (M_OE123)
/LCD_board/EP_A2: U6.38, U8.15 (M_CKV)
/LCD_board/EP_A3: U6.39, U8.16 (M_STV_IN)
/LCD_board/EP_D2: U6.19, U8.1 (M_EPD_PAEL_ON)
/LCD_board/EP_D3: U6.18, U8.2 (M_EPD_BORDER)
/LCD_board/EP_D4: U6.25, U8.3 (M_SD_CS)
/LCD_board/EP_D5: U6.31, U8.4 (M_EPD_PWM)
/LCD_board/EP_D6: U6.27, U8.5 (M_EPD_RESET)
/LCD_board/EP_D7: U6.1, U8.6 (M_EPD_BUSY)
/LCD_board/EP_D8: U6.28, U8.7 (M_EPD_DISCHARGE)
/LCD_board/EP_D9: U6.29, U8.8 (M_WORD_STOCK_CS)
/LCD_board/EP_D10: U6.30, U8.9 (M_EPD_CS)
/LCD_board/GND2: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.2, C21.1, C22.2, C23.2, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, CON2.6 (GND), CON3.6 (GND), JP1.1, Q9.S, Q10.S, Q11.S, R27.2, R28.2, R36.2, R37.2, R38.2, SW5.2, SW6.2, SW7.2, U3.5, U3.15, U3.23, U3.35, U3.43, U6.5, U6.15, U6.23, U6.35, U6.43, U7.4 (GND), U9.4 (GND), U10.10 (R/W), U10.12 (V0), U12.4 (VSS), U13.2 (GND), U13.5 (TestI), U13.9 (GND), U13.12 (GPIO), U13.18 (PIRQ), U13.23 (GND), U13.24 (ATest), U13.32 (GND), U14.6 (EEDATA), U14.7 (GND), U14.8 (~BUSPWR), U14.27 (TSTPLL/48MCLK), U14.28 (GND), U14.31 (TSTMODE), U16.1 (GND), U16.5 (SDO), U16.7 (GND), U17.2 (GND), X2.2 (case), X2.4, X3.2 (case), X3.4; also elsewhere on the board
/LCD_board/LCD_B4: U3.30, U10.4 (DB4)
/LCD_board/LCD_B5: U3.29, U10.3 (DB5)
/LCD_board/LCD_B6: U3.31, U10.2 (DB6)
/LCD_board/LCD_B7: U3.32, U10.1 (DB7)
/LCD_board/LCD_E1: U3.28, U10.9 (E1)
/LCD_board/LCD_E2: U3.25, U10.15 (E2)
/LCD_board/LCD_ON: Q10.G, R37.1, U3.26
/LCD_board/LCD_RS: U3.27, U10.11 (RS)
/LCD_board/MISO_A: CON2.1 (MISO), U3.11, U11.6 (MISO)
/LCD_board/MISO_B: CON3.1 (MISO), U6.11, U8.12 (M_MISO)
/LCD_board/MOSI_A: CON2.4 (MOSI), U3.10, U11.5 (MOSI)
/LCD_board/MOSI_B: CON3.4 (MOSI), U6.10, U8.10 (M_MOSI)
/LCD_board/M_GND2: Q9.D, U8.19 (M_GND)
/LCD_board/NRF_CE: U3.20, U11.2 (CE)
/LCD_board/NRF_CSN: U3.18, U11.3 (CSN)
/LCD_board/NRF_ON: Q11.G, R38.1, U3.19
/LCD_board/OC4: U14.22 (~OVRCUR4), U17.3 (~OC)
/LCD_board/OVCR: R41.1, U14.10 (~OVRCUR1), U14.14 (~OVRCUR2), U14.18 (~OVRCUR3)
/LCD_board/PWR4: U14.21 (~PWRON4), U17.4 (~EN)
/LCD_board/RST_A: CON2.5 (RST), R25.2, SW5.4, U3.13
/LCD_board/RST_B: CON3.5 (RST), R26.2, SW6.4, U6.13
/LCD_board/SCK_A: CON2.3 (SCK), U3.9, U11.4 (SCK)
/LCD_board/SCK_B: CON3.3 (SCK), U6.9, U8.11 (M_SCK)
/LCD_board/SCL: R31.2, U12.6 (SCK), U13.29 (SM_CLK), U16.4 (SCK); also elsewhere on the board
/LCD_board/SDA: R30.2, U12.5 (SDA), U13.30 (SM_DAT), U16.3 (SDI); also elsewhere on the board
/LCD_board/V3.32: C15.1, C16.1, C17.1, C18.1, C21.2, C23.1, R29.2, R30.1, R31.1, R32.2, R34.2, R35.1, R41.2, U8.17 (M_VCC_3V3), U12.8 (VCC), U13.1 (Vcc), U13.8 (Vcc), U13.19 (ATest), U13.20 (TWI_Wakeup), U13.21 (ATest), U13.22 (Vcc), U14.3 (VCC), U14.25 (Vcc), U14.26 (~EXTMEM), U16.6 (VDDIO), U16.8 (VDD); also elsewhere on the board
/LCD_board/VUSB4: U9.1 (VCC), U17.1 (OUT)
/LCD_board/Vcc2: CON2.2 (VCC), CON3.2 (VCC), R25.1, R26.1, U3.2, U3.7, U3.14, U3.24, U3.34, U3.44, U6.2, U6.7, U6.14, U6.24, U6.34, U6.44, U7.1 (VCC), U8.18 (M_VCC_5V), U10.14 (VDD), U10.17 (LED+), U11.1 (V_3.3), U17.5 (IN); also elsewhere on the board
/LCD_board/~RST: C19.2, R32.1, U13.17 (LRESET), U14.4 (~RESET)
unnamed: JP1.2, U13.6 (XTAMPER)
unnamed: R33.1, U14.29 (XTAL2)
unnamed: Q11.D, U11.8 (GND)
unnamed: Q10.D, U10.13 (VSS)
unnamed: Q9.G, R36.1, U6.12
unnamed: R35.2, U16.2 (CSB)
unnamed: R29.1, U12.1 (CS)
unnamed: C13.1, U3.6
unnamed: C9.1, X2.3
unnamed: C10.1, X2.1
unnamed: C10.2, U3.16
unnamed: C20.1, R33.2, X4.1
unnamed: R27.1, U3.33
unnamed: R28.1, U6.33
unnamed: R46.2, U14.24 (DP4)
unnamed: R47.2, U14.23 (DM4)
unnamed: R44.1, U14.15 (DM2)
unnamed: R43.1, U14.12 (DP1)
unnamed: R42.1, U14.11 (DM1)
unnamed: R45.1, U14.16 (DP2)
unnamed: R34.1, R39.1, U14.1 (DP0)
unnamed: R40.1, U14.2 (DM0)
unnamed: C9.2, U3.17
unnamed: C24.2, SW7.1, U10.18 (LED-)
unnamed: C11.1, X3.3
unnamed: C12.1, X3.1
unnamed: C12.2, U6.16
unnamed: C11.2, U6.17
unnamed: C14.1, U6.6
unnamed: C22.1, U14.30 (XTAL1), X4.2

Parts:
U15: PIXEL_QI_IPEX_BREAKOUT
U18: LCD_50PIN

Connections:
/LCD_board/Din+: U18.44 (USB_VID_P); also elsewhere on the board
/LCD_board/Din-: U18.43 (USB_VID_N); also elsewhere on the board
/LCD_board/GND2: U15.19 (GND), U18.5 (GND), U18.45 (GND); also elsewhere on the board
/LCD_board/SCL: U18.3 (I2C3_SCL); also elsewhere on the board
/LCD_board/SDA: U18.4 (I2C3_SDA); also elsewhere on the board
/LCD_board/V3.32: U15.4 (LCD_VCC), U15.5 (LCD_VCC), U15.6 (LCD_VCC), U18.36 (LCD_VCC_SW), U18.37 (LCD_VCC_SW), U18.38 (LCD_VCC_SW), U18.39 (LCD_VCC_SW); also elsewhere on the board
/LCD_board/Vcc2: U18.42 (USB_VID_P5V); also elsewhere on the board
unnamed: U15.10 (GND), U18.14 (GND)
unnamed: U15.7 (GND), U18.17 (GND)
unnamed: U15.8 (LVDS_CLK_P), U18.16 (LVDS0_CLK_P)
unnamed: U15.9 (LVDS_CLK_N), U18.15 (LVDS0_CLK_N)
unnamed: U15.11 (LVDS_TX2_P), U18.13 (LVDS0_TX_2_P)
unnamed: U15.12 (LVDS_TX2_N), U18.12 (LVDS0_TX_2_N)
unnamed: U15.13 (GND), U18.11 (GND)
unnamed: U15.14 (LVDS_TX1_P), U18.10 (LVDS0_TX_1_P)
unnamed: U15.15 (LVDS_TX1_N), U18.9 (LVDS0_TX_1_N)
unnamed: U15.16 (GND), U18.8 (GND)
unnamed: U15.20 (LCD_EN), U18.2 (LCD_BL_ON)
unnamed: U15.3 (GND), U18.40 (GND), U18.41 (GND)
unnamed: U15.21 (PWM_IN), U18.1 (GPIO_PWM1)
unnamed: U15.17 (LVDS_TX0_P), U18.7 (LVDS0_TX_0_P)
unnamed: U15.18 (LVDS_TX0_N), U18.6 (LVDS0_TX_0_N)
unnamed: U15.1 (LCD_BL), U15.2 (LCD_BL), U18.46 (LCD_BL_VDD), U18.47 (LCD_BL_VDD), U18.48 (LCD_BL_VDD), U18.49 (LCD_BL_VDD), U18.50 (LCD_BL_VDD)

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
Board: 2 copper layers, 141.3 x 54.8 mm, 143 parts (51 on the bottom side), 190 nets.

File laptop_kbrd_BOM.csv:

22pF,18,C2 C3 C9 C10 C11 C12 C20 C22 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34,12065A220JAT2A
2.2nF,3,C16 C18 C21,12061A222KAT2A
0.1uF,6,C1 C8 C15 C17 C23 C24,12065C104KAT2A
1uF,6,C4 C5 C6 C13 C14 C19,12063C105KAT2A
100uF,1,C7,TMCMA0G107MTRF
AVR-ISP-6-DR,3,CON1 CON2 CON3,54202-G0803ALF
FPGA_CLK,1,D1,SML-LXFT1206SOC-TR
FPGA_WP,1,D2,SML-LXFT1206SOC-TR
FPGA_MISO,1,D3,SML-LXFT1206SOC-TR
FPGA_MOSI,1,D4,SML-LXFT1206SOC-TR
FPGA_HOLD,1,D5,SML-LXFT1206SOC-TR
FPGA_CS,1,D6,SML-LXFT1206SOC-TR
LED_YELLOW,1,D7,SML-LXL1206YC-TR
LED_BLUE,1,D8,SML-LXR1206USBC-TR
RSA5M,1,D9,RSA5MGTR
0,1,DNP1,
JUMPER,1,JP1, 382811-8 & 5-146871-1
CASE_OPEN,2,K1 K2,“046277003001883+”
CD4051,3,MUX1 MUX2 MUX3,CD4051BM96
CPU_FAN,1,P1,
MOSFET_N,10,Q1 Q2 Q3 Q4 Q5 Q6 Q7 Q9 Q10 Q11,2N7002W
ALS_PT19,1,Q8,ALS-PT19-315C/L177/TR8
27 Ohms,10,R39 R40 R42 R43 R44 R45 R46 R47 R48 R49,RC1206FR-0727RL
1K,10,R2 R5 R7 R10 R12 R17 R18 R21 R30 R31,AS12J1001ET
1.5K,2,R33 R34,CRCW12061K50FKEA
4.7K,2,R29 R35,ERJ-8ENF4701V
10K,23,R1 R3 R4 R6 R8 R9 R11 R13 R14 R15 R16 R19 R20 R22 R24 R25 R26 R27 R28 R36 R37 R38 R41,AS12J1002ET
15K,1,R32,
47K,1,R23,ERJ-8ENF4702V
MCU_RST,3,SW1 SW5 SW6,KPT-1187B
BT_ASSCN,1,SW2,KPT-1187B
POWER,1,SW3,KPT-1187B
CASE_PUSH,1,SW4,3FSH9
SPST,1,SW7,AS11BH
XF2M-3015-1A,1,U5,XF2M-3015-1A
USB_CAM,1,U7,4 pins
EPAPER_V2,1,U8,many pins
USB_A_FEMALE,1,U9,KUSBEX-ASFS1N-W
NHD-0440AZ-FL-YBW,1,U10,NHD-0440AZ-FL-YBW
NRF24L01+,1,U11,Sparkfun RP-SMA
ATAES132A,1,U12,ATAES132A-SH-ER-T
AT97SC3205T,1,U13,AT97SC3205T-H3M46-00CT-ND
PIXEL_QI_IPEX_BREAKOUT,1,U15,
BME280,1,U16,BME280
TPS2041B,1,U17,TPS2041BDBVR
LCD_50PIN,1,U18,XF2M-5015-1A & 15020-0555
ATMEGA32U4-AU,1,U1,ATMEGA32U4-AU
RT9706,1,U2,RT9706GB
ATMEGA32U4,2,U3 U6,ATMEGA32U4-AU
0WX4JF,1,U4,0WX4JF backlit Dell
TUSB2046BVFR,1,U14,TUSB2046BVFR
6MHz,1,X4,HCM49-6.000MABJ-UT
XTAL 16MHz,3,X1 X2 X3,406C35E16M00000

## Commit log

2015-11-10 Schematic done. First commit.
2015-11-11 Begun making new footprints.
2015-11-11 Begun making new footprints. 3 left.
2015-11-14 All footprints done. Hopefully, FPC header has right parity.
2015-11-14 We'll need to do something about track clearances in PCB.
2015-11-17 Should I remove RCLAMP?
2015-11-17 Removed RCLAMP
2015-11-19 Added lidsense. Mounting holes.
2015-12-04 Modified pdf schematic.
2016-03-06 New components for the LCD controller.
2016-03-07 Gerbers left to be created.
2016-03-09 Fixed spin_half.lib issue, and removed sch file from gitignore.
2016-03-09 Added BOM csv file.
2016-03-10 Changed internal Edge cuts to Silkscreen double lines for cutting with fret saw later. Generated and zipped Gerber files and drill file. Tested with Oshpark.
2016-03-18 Modified footprint for 3pin_FPC connector (K1 and K2).
2016-03-29 Added decals
2016-04-30 First commit with license and readme file.
2016-05-17 Changed TPM chip digikey part number to one that is available right now. 4x4 QFN packages are rare. Note to self: change layout to TSSOP in future version.
2016-07-26 Future-proofed license in readme.
2016-08-12 Swapped EPIT1_EPIT0 with GPT_CMPOUT3. Fixed usb d+ d- switch issue.
2016-08-15 Added 5V breakout to kbrd panel. Changed BOM to reflect proper i2c (vs spi) encrypted eeprom chip. Made gerber files for kbrd only.
2018-01-28 Adding LVDS 50 pin header to LCD front panel board. Also redoing reset pin for tusb2046b and crypto chip using RC circuit.
2018-01-31 New footprints in.
2018-02-17 50 pin FFC cable now goes from motherboard to LCD board.
2018-02-17 LCDbrdonly gerber folder created.
2018-02-18 Minor changes. Moved some text to silkscren layer
